# Repository HB9UF/AIOB

File README.md:

# AIOB
This is the Ham Radio *All-in-one-Box*. It is a fork of the [AIOC](https://github.com/skuep/AIOC) project by [skuep](https://github.com/skuep). AIOC is a small adapter designed to plug directly into a radio, offering a sound-card and a serial interface ("COM port") via its USB-C interface (see below). AIOC developed in this fork differs from AIOC in a number of ways:

- The PCB was redesigned to fit in a small extruded [aluminum box](https://de.aliexpress.com/item/1005002758276938.html?algo_exp_id=265cb891-2734-45df-9939-85fcaf4d986a-10) instead of an overmolded enclosure. This renders it compatible to radios that lack the Kenwood-style connector that is integral to the AIOC design.
- The wiring between AIOB and the radio is implemented using cables with TRRS connectors instead of the aforementioned solution.
- Having a larger box at disposal allowed us to increase the size of the passive components to 0805. This way, we can also use this project as intermediate level SMD practising kit. The layout has been implemented with this in mind. In consequence, electrically better part placement would be possible in some cases but we focused on ease of assembly at the expense of this.
- Since [some claims exist](https://www.swiss-artg.ch/index.php?id=61&tx_news_pi1%5Bnews%5D=309&tx_news_pi1%5Bcontroller%5D=News&tx_news_pi1%5Baction%5D=detail&cHash=2c1ab05b8925a4b1715bc4929fcc3d95) that devices of this kind would perform better when galvanically isolated, we added an isolated 5 V DC/DC converter along with a [Analog Devices ADuM 3160](https://www.analog.com/en/products/adum3160.html) to test this hypothesis.
- Extra circuitry was added to sense the radio sqleuch (COS/TOS).
- While the AIOC can support Dual-PTT HTs, this feature is missing from the AIOB.

In addition to the intended applications of AIOC, we hope to use AIOB as EchoLink interface.

**Note that AIOC is currently still being tested! Our AIOB fork is even more bleeding edge, we are in the process of assembling the first PCB revision.** Please read this README carefully before ordering anything.

## Features ##
- Cheap & Hackable Digital mode USB interface (similar to digirig, mobilinkd, etc...)
- Programming Cable Function via virtual Serial Port
- Compact form-factor (DIY overmolded enclosure is currently TBD)
- Based on easy-to-hack **STM32F302** with internal ADC/DAC (Programmable via USB bootloader using [DFU](#how-to-program))

## Compatibility
### Software
  - [Direwolf](#notes-on-direwolf) as AX.25 modem/APRS en+decoder/...
  - [APRSdroid](#notes-on-aprsdroid) as APRS en+decoder
  - [CHIRP](#notes-on-chirp) for programming
  - ... and more

### Tested Radios (so far)
  - Wouxun UV-9D Mate (CHIRP + APRS)
  - Baofeng UV-5R (CHIRP + APRS)
  - BTECH 6X2 (CHIRP) 

## Ordering and Assembly

*TODO*

## How To Build
For building the firmware, clone the repository and initialize the submodules. Create an empty workspace with the STM32CubeIDE and import the project.
  - ``git clone <repositry url>``
  - ``git submodule update --init``
  - Start STM32CubeIDE and create a new workspace under ``<project-root>/stm32``
  - Choose File->Import and import the ``aioc-fw`` project in the same folder without copying
  - Select Project->Build All and the project should build. Use the Release build unless you specifically want to debug an issue

## How To Program
### Initial programming
The following steps are required for initial programming of the AIOB:
- Short outermost pins on the programming header. This will set the device into bootloader mode in the next step.
- Connect USB-C cable to the AIOB PCB
- Use a tool like ``dfu-util`` to program the firmware binary from the GitHub Releases page like this:
  ````
  dfu-util -a 0 -s 0x08000000 -D aioc-fw-x-y-z.bin
  ````
  __Note__ that a ``libusb`` driver is required for this. On Windows there are additional steps required as shown [here](https://yeswolf.github.io/dfu) (*DFuSe Utility and dfu-util*). On other operating systems (e.g. Linux, MacOS), this just works ™ (provided libusb is installed on your system).
  On Linux (and MacOS), your user either needs to have the permission to use libusb (``plugdev`` group) or you might need to use ``sudo``.
- Remove short from first step, unplug and replug the device, it should now enumerate as the AIOB device

### Firmware updating
Once the AIOB has firmware loaded onto it, it can be re-programmed without the above BOOT sequence by following these steps.

__Note__ This requires firmware version >= 1.2.0. For older firmwares, the initial programming sequence above is required for updating the firmware.
- Run ``dfu-util`` like this
  ````
  dfu-util -d 1209:7388 -a 0 -s 0x08000000:leave -D aioc-fw-x-y-z.bin
  ````

This will reboot the AIOB into the bootloader automatically and perform the programming. 
After that, it automatically reboots the AIOB into the newly programmed firmware.

__Note__ Should you find yourself with a bricked AIOB, use the initial programming sequence above

## How To Use
The serial interface of the AIOB enumerates as a regular COM (Windows) or ttyACM port (Linux) and can be used as such for programming the radio as well as PTT (Asserted on ``DTR=1`` and ``RTS=0``).

__Note__ before firmware version 1.2.0 of the original project, PTT was asserted by ``DTR=1`` (ignoring RTS) which caused problems with certain radios when using the serial port for programming the radio e.g. using CHIRP.

The soundcard interface of the AIOB gives access to the audio data channels. It has one mono microphone channel and one mono speaker channel and currently supports the following baudrates:
  - 48000 Hz (preferred)
  - 32000 Hz
  - 24000 Hz
  - 22050 Hz (specifically for APRSdroid, has approx. 90 ppm of frequency error)
  - 16000 Hz
  - 12000 Hz
  - 11025 Hz (has approx. 90 ppm of frequency error)
  - 8000 Hz

Since firmware version 1.2.0, a CM108 style PTT interface is available for public testing. This interface works in parallel to the COM-port PTT.
Direwolf on Linux is confirmed working, please report any issues. Note that currently, Direwolf reports some warnings when using the CM108 PTT interface on the AIOB. 
While they are annoying, they are safe to ignore and require changes in the upstream direwolf sourcecode. See https://github.com/wb2osz/direwolf/issues/448 for more details.

Please refer to the README file of the original project for detailed usage notes.

## KiCad design kicad/k1-aioc/k1-aioc.kicad_pcb

Parts:
C1, C4, C5, C7, C9, C11, C15: 100n; C_0805_2012Metric; LCSC C720961
C2, C3: 22p/NP0; C_0805_2012Metric; LCSC C376875
C6, C8, C10, C13, C14, C16, C17, C18, C19: 4.7u/10V/X5R; C_0805_2012Metric; LCSC C5375826
C12: 10n/NP0; C_0805_2012Metric; LCSC C237168
D1: LED_RGBK; LED_Kingbright_APFA3010_3x1.5mm_Horizontal; DIGIKEY 754-2148-1-ND
FB1, FB2, FB3: 600R@100MHz; L_0805_2012Metric; LCSC C124100
J1: 12401832E402A; USB_C_Receptacle_Amphenol_12401832E40-2A; LCSC C464604
J2: GND; PinHeader_1x02_P2.54mm_Vertical
J3: Conn_01x07_Male; PinHeader_1x07_P1.27mm_Vertical
J4: AUDIO; Jack_3.5mm_PJ320E_Horizontal; LCSC C2939183
J5: CAT; Jack_3.5mm_PJ320E_Horizontal; LCSC C2939183
Q1, Q2: PZT2222A; SOT-223-3_TabPin2; LCSC C7603308
R1, R2, R7, R8, R19, R20: 24R; R_0805_2012Metric; LCSC C3017901
R3, R5, R6, R15, R16: 5.1K; R_0805_2012Metric; LCSC C104375
R4, R10, R18: 2.2K; R_0805_2012Metric; LCSC C104106
R9: 1.5K; R_0805_2012Metric; LCSC C2907216
R11: N.M.; R_0805_2012Metric
R12: 10K; R_0805_2012Metric; LCSC C3016734
R13, R14, R17, R21, R22, R23: 220R; R_0805_2012Metric; LCSC C3016631
U1: CRE1S0505SC; Converter_DCDC_Murata_CRE1xxxxxxSC_THT; DIGIKEY 811-3196-ND
U2: ADUM3160; SOIC-16W_7.5x10.3mm_P1.27mm; LCSC C108501
U3: STM32F373CBTx; LQFP-48_7x7mm_P0.5mm; LCSC C94046
U4, U5: TLV1117LV-33; SOT-223-3_TabPin2; LCSC C15578
Y1: 8MHz/20pF; Crystal_SMD_5032-2Pin_5.0x3.2mm; LCSC C115962

Connections:
+3.3VA: C9.1, C10.1, FB3.2, R15.1, U3.9 (VDDA), U3.24 (VDDSD), U3.25 (VREFSD+)
+3V3: C5.1, C7.1, C19.1, J3.7, R9.1, U3.1 (VBAT), U3.17 (VDD), U3.36 (PF7), U3.48 (VDD), U4.2 (VO)
/AFIN: C12.1, R15.2, R16.2, R18.1, U3.20 (PB2)
/AFOUT: R12.2, U3.14 (PA4)
/BOOT0: J3.1, R4.2, U3.44 (BOOT0)
/COS: J5.R2, R19.1
/DAC_ATTEN: R11.2, U3.13 (PA3)
/LED_B: R21.2, U3.27 (PB15)
/LED_G: R22.2, U3.26 (PB14)
/LED_R: R23.2, U3.28 (PD8)
/NRST: C1.1, J3.3, U3.7 (NRST)
/OSCIN: C2.1, U3.5 (PF0), Y1.1
/OSCOUT: C3.1, U3.6 (PF1), Y1.2
/PTT1: R10.1, U3.11 (PA1)
/RADIO-MIC: C17.2, J4.R1
/RADIO-PTT: J4.R2, R20.1
/RADIO-RX: J5.T, R13.1
/RADIO-SPK: C16.2, J4.T
/RADIO-TX: J5.R1, R14.1
/SWCLK: J3.6, U3.37 (PA14)
/SWDIO: J3.4, U3.34 (PA13)
/SWO: J3.2, U3.39 (PB3)
/USART-RX: R14.2, U3.31 (PA10)
/USART-TX: R13.2, U3.30 (PA9)
/USB-DN-D: R8.1, U3.32 (PA11)
/USB-DN-H: R1.1, U2.6 (UD-)
/USB-DP-D: R7.1, R9.2, U3.33 (PA12)
/USB-DP-H: R2.1, U2.7 (UD+)
GND: C1.2, C2.2, C3.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C18.2, C19.2, D1.2 (K), J2.1, J2.2, J3.5, J4.S, J5.S, Q1.3 (E), Q2.3 (E), R4.1, R16.1, R17.1, U1.3 (-VOUT), U2.9 (GND2), U2.15 (GND2), U3.8 (VSSA), U3.23 (VSSSD), U3.35 (PF6), U3.47 (VSS), U4.1 (GND), U5.1 (GND)
GNDREF: C4.2, C6.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), R3.1, R5.1, U1.1 (-VIN), U2.2 (GND1), U2.8 (GND1)
unnamed: C4.1, U2.3 (VDD1), U2.4 (PDEN), U2.5 (SPU)
unnamed: C6.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U1.2 (+VIN), U2.1 (VBUS1)
unnamed: C8.1, FB1.1, FB2.2, U1.4 (+VOUT), U2.16 (VBUS2)
unnamed: C11.1, R6.2, U2.13 (SPD), U2.14 (VDD2)
unnamed: C13.1, FB1.2, U5.3 (VI)
unnamed: C14.1, FB2.1, U4.3 (VI)
unnamed: C15.1, C17.1, R11.1, R12.1, R17.2
unnamed: C16.1, R18.2
unnamed: C18.1, FB3.1, U5.2 (VO)
unnamed: D1.1 (RA), R23.1
unnamed: D1.3 (GA), R22.1
unnamed: D1.4 (BA), R21.1
unnamed: J1.A5 (CC1), R5.2
unnamed: J1.A6 (D+), J1.B6 (D+), R2.2
unnamed: J1.A7 (D-), J1.B7 (D-), R1.2
unnamed: J1.B5 (CC2), R3.2
unnamed: Q1.1 (B), R10.2
unnamed: Q1.2 (C), R20.2
unnamed: Q2.1 (B), R19.2
unnamed: Q2.2 (C), U3.29 (PA8)
unnamed: R6.1, U2.12 (PIN)
unnamed: R7.2, U2.10 (DD+)
unnamed: R8.2, U2.11 (DD-)

Notes on the sheet:
GPIOA O.D.
STM Disco SWD Header
Short Pins for Bootloader
SDADC1_AIN4P/ADC2_IN12
USART1-TX
GPIOA P.P.
ENUMERATION
DAC1_OUT1
Compatible to STM32F302CBTx (no DS-ADC)
USART1-RX

Board: 2 copper layers, 47.5 x 80.0 mm, 61 parts (1 on the bottom side), 53 nets.

Other parts of the board:
GND: GND
SYM: Symbol_OSHW-Logo_SilkScreen_07Jul2012; Symbol_OSHW-Logo_SilkScreen

## Commit log

2024-02-07 Changing most parts from 0603 to 0805
2024-02-07 Swapping MIC5330 for two TLV1117LV regulators
    Since these are easier to solder. Using two regulators to maintain
    good PSSR, but this is probably overkill.
2024-02-08 Changing C7 from 4.7uF to 100nF
    There is sufficient bulk capacitance on the 3.3V rail but we want
    to decouple both VDD inputs of the uC equally.
2024-02-08 Removing tooling holes
2024-02-08 3V3 rail for USB-DP should point up
2024-02-10 Adding USB isolation
    - Isolated 5V DC/DC converter
    - ADUM3160 USB Isolator
    - 1.5k PU optional (handled by ADUM3160)
2024-02-10 Removing PTT2, swapping Q1
    - PTT2 is not required, removing circuitry
    - Q1 was dual transistor, replaced with PZT2222A
    - 22R --> 24R for Q1 collector (minimizing BOM)
    - Cleaned up schematic
2024-02-10 Adding two TRRS jacks for I/O (digirig pinout)
2024-02-10 Adding general purpose input (e.g. use for COS)
2024-02-10 Removing JLC part numbers for 0603 --> 0805 parts
2024-02-13 Replacing discrete LEDs with RGB LED (different pins)
2024-02-16 Extensive PCB rework for new form factor
2024-02-16 Adding some more via stitching
2024-02-16 Silk screen: Name, acknowledgement and revision
2024-02-16 Including HB9UF footprint library (for logo and GND)
2024-02-16 Silk Screen artwork on pcb back
2024-02-16 Adding project URLs to back of PCB
2024-02-16 Adding GND point for scope probe
2024-03-10 Adding LCSC (and some DIGIKEY) part numbers
2024-03-10 Improved placement of uC decoupling caps
2024-03-10 Adding TRRS pinout to silk screen
2024-03-10 Re-running annotate to renumber
    We shuffled and changed quite a number of parts in this branch, so it
    makes sense to finally renumber the part annotations.
2024-03-10 Updated documentation
2024-03-10 Removing AIOC 3d files

Notices in the files:
kicad/k1-aioc/k1-aioc.kicad_pcb:
Rev 1.0, (c) 2024, MIT License
HB9UF All-In-One-Box, Rev 1.0, (c) 2024 M. Weyland HB9FRV, based on work by skuep
